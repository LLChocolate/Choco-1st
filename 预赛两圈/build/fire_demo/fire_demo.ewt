<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\Car_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\define.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\define.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\fire_drivers_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\ISR_FUN.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\mymath.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\stdlib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\uif.c</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\arm_cm4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\vectors.h</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\adc\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\BEEP\beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\cmt\cmt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\delay\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\dial_switch\dial_switch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\dma\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\dma\dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\exti\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\filter\filter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\FTM\FTM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\getspeed\getspeed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\gpio\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\i2c_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\image_process\image_process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\LCD\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\LED\LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lptmr\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\mcg\mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\spi\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\key\mykey.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\power\mypower.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\PWM\myPWM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\OV7725.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\PID\pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\PIT\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\port\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\port\port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\sdhc\sdhc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\sdhc\sdhc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\uart\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\wdog\wdog.c</name>
    </file>
  </group>
  <group>
    <name>header</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\arm_common_tables.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\arm_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cm0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cm4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cm4_simd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\LIB\CMSIS\iar_cortexM4l_math.a</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app_mydriver\k60_fire.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\headers\MK60DZ10.h</name>
    </file>
  </group>
</project>


